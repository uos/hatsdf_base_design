SRC_URI += "file://interfaces"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
