SRC_URI += "file://fstab"
FILESEXTRAPATHS_prepend := "${THISDIR}/base-files:"
dirs755_prepend := "/data "
